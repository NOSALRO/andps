Commit message: init gym env, + sac train

File: ANDPS/rl_push/robots/star/star.urdf (robot description, URDF)
Before this commit: robot star, 1 links, 0 joints
Links:
- link base_link: mass 0.01 -> 0.1
