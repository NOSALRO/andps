Commit message: add target and box to demo

File: ANDPS/rl_push/robots/table/table.urdf (robot description, URDF)
Before this commit: robot table, 1 links, 0 joints
Links:
- link base_link: mass 30 -> 60
